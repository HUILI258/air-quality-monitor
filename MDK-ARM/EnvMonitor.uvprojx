# Keil uVision project EnvMonitor.uvprojx, settings and files
target EnvMonitor (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: EnvMonitor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Drivers\LED;..\Drivers\Button;..\Drivers\Buzzer;..\Drivers\OLED;..\Drivers\DHT22;..\Drivers\BH1750;..\Drivers\HC_SR04;..\Drivers\ESP8266;..\App;..\Drivers\FreeRTOS\include;..\Drivers\FreeRTOS\portable\RVDS\ARM_CM3;..\Core\Inc;..\Drivers\SCD30;..\Drivers\Noise
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group App
    ../App/: alarm.c app.c menu.c aqi.c
  group Drivers
    ../Drivers/BH1750/: bh1750.c
    ../Drivers/Button/: button.c
    ../Drivers/Buzzer/: buzzer.c
    ../Drivers/DHT22/: dht22.c
    ../Drivers/ESP8266/: esp8266.c
    ../Drivers/HC_SR04/: hc_sr04.c
    ../Drivers/LED/: led.c
    ../Drivers/OLED/: oled.c
    ../Drivers/SCD30/: scd30.c
    ../Drivers/Noise/: noise.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/Kernel
    ../Drivers/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ../Drivers/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Drivers/FreeRTOS/portable/MemMang/: heap_4.c
  group App/Tasks
    ../App/: task_alarm.c task_button.c task_buzzer.c task_cloud.c task_display.c task_sensor.c task_shared.c
software components: CMSIS:CORE 4.3.0
